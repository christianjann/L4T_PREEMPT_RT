## drivers/misc/nv-sensorhub-ldisc/Kconfig
```kconfig
config NV_SENSORHUB
	tristate "Line discipline for Sensorhub"
	depends on TTY
	help
		TTY line discipline for sensorhub stream
```
